# Keil uVision project gimbal.uvprojx, settings and files
target gimbal (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gimbal +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../APP;../BSP/BSP_CAN;../BSP/BSP_TIM;../TASK;../Core/Src;../BSP/BSP_IMU;../components/algorithm;../components/devices;../BSP/BSP_SPI;../BSP/BSP_UART;../components/controller;../components/fifo;../components/crc8_crc16;../BSP/BSP_Referee
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group APP
    ../APP/: imu.c can_receive.c led.c math.c pid.c remote_control.c blueteeth.c buzzer.c referee.c
  group BSP
    ../BSP/BSP_CAN/: bsp_can.c
    ../BSP/BSP_TIM/: delay.c
    ../BSP/BSP_IMU/: bsp_imu.c bsp_imu_pwm.c
    ../BSP/BSP_SPI/: bsp_spi.c
    ../BSP/BSP_UART/: BSP_UART.c
    ../BSP/BSP_Referee/: bsp_referee.c
  group TASK
    ../TASK/: chassis_task.c gimbal_task.c gimbal_task_behaviour.c RC_task.c Sent_Task.c TIM3_cnt_task.c vision_task.c shoot_task.c lk_pitch_turn.c buzzer_task.c gimbal_calibration_task.c
  group Algorithm
    ../components/algorithm/: MahonyAHRS.c user_lib.c
  group devices
    ../components/devices/: BMI088driver.c BMI088Middleware.c ist8310driver.c ist8310driver_middleware.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Components
    ../components/fifo/: fifo.c
    ../components/crc8_crc16/: crc8_crc16.c
software components: CMSIS:CORE 4.3.0
